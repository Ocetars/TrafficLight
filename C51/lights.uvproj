# Keil uVision project lights.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: lights +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\includes
  group Source Group 1
    ./: STARTUP.A51 trafficLight.c
